# Keil uVision project ota_tester_pca10040_s332_po.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S332 SOFTDEVICE_PRESENT
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\include\boot_common;..\..\..\include;..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DANT_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=4,-DS332,-DSOFTDEVICE_PRESENT
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20001e30 size 0xe1d0
  link misc: --diag_suppress 6330
  group Application
    ../../../../: ant_boot_settings_api.c
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group nRF_ANT
    ../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
